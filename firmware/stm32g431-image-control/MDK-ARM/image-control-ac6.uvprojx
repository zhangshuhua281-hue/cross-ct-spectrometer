# Keil uVision project image-control-ac6.uvprojx, settings and files
target STM32G431RBTx (6070000::V6.7::.\ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20007FFF) IRAM(0x10000000-0x100027FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: image-control +hex
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32G431xx,USE_HAL_DRIVER
  c include: ..\\Core\\Inc;..\\App\\Inc;..\\BSP\\Inc;..\\Drivers\\CMSIS\\Include;..\\Drivers\\CMSIS\\Device\\ST\\STM32G4xx\\Include;..\\Drivers\\STM32G4xx_HAL_Driver\\Inc;..\\Drivers\\STM32G4xx_HAL_Driver\\Inc\\Legacy
  memory RVCT9: RAM 0x10000000 size 0x2800
  group Application
    ..//App//Src//: app_main.c app_processing.c app_pipeline.c app_group_stats.c
  group BSP
    ..//BSP//Src//: bsp_led.c bsp_uart.c
  group Core
    ..//Core//Src//: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Startup
    ..//Core//Startup//: startup_stm32g431xx.s
  group CMSIS
    ..//Core//Src//: system_stm32g4xx.c
  group HAL
    ..//Drivers//STM32G4xx_HAL_Driver//Src//: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
software components: CMSIS:CORE 5.3.0
