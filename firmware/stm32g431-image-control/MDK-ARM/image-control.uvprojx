# Keil uVision project image-control.uvprojx, settings and files
target STM32G431RBTx (ARM-ADS)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: image-control +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G431xx,USE_HAL_DRIVER
  c include: ..\\Core\\Inc;..\\App\\Inc;..\\BSP\\Inc;..\\Drivers\\CMSIS\\Include;..\\Drivers\\CMSIS\\Device\\ST\\STM32G4xx\\Include;..\\Drivers\\STM32G4xx_HAL_Driver\\Inc;..\\Drivers\\STM32G4xx_HAL_Driver\\Inc\\Legacy
  library: MicroLIB
  link misc: --scatter="image-control_armcc.sct"
  group Application
    ..//App//Src//: app_main.c app_processing.c app_pipeline.c app_group_stats.c
  group BSP
    ..//BSP//Src//: bsp_led.c bsp_uart.c
  group Core
    ..//Core//Src//: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Startup
    ..//Core//Startup//: startup_stm32g431xx.s
  group CMSIS
    ..//Core//Src//: system_stm32g4xx.c
  group HAL
    ..//Drivers//STM32G4xx_HAL_Driver//Src//: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
software components: CMSIS:CORE 5.0.1
